inherit externalsrc
EXTERNALSRC = "/home/google/SymonSaysLLC/Symoneural-Build/src/autotools/source/autoconf"

# initial_rev .: 44d712a26b0e14931bf2df57e2c9b80a2747dfce
