inherit externalsrc
EXTERNALSRC = "/home/google/SymonSaysLLC/Symoneural-Build/src/autotools/source/libtool"

# initial_rev .: 309bb53a8adfb22c6e5869cc8da049bf123e5438

# initial_rev gl-mod/bootstrap: bfdcc277cd237fde115d3aa972add7608d348b90

# initial_rev gnulib: 491f1bb7d3049f3ab7825f3ee665c209658e9965
