inherit externalsrc
EXTERNALSRC = "/home/google/SymonSaysLLC/Symoneural-Ravencalc/src/numerics/source/scipy"

# initial_rev .: e4e854eaa8f18d807cd3496028e257e36caa93cc

# initial_rev doc/source/_static/scipy-mathjax: 3d21c58225c09243d5a088b1557654d280925e02

# initial_rev subprojects/array_api_compat/array_api_compat: 145bd7d3f41d0cf98f0a7f35ba7e255874dec948

# initial_rev subprojects/array_api_extra: 02afc63f8133caad1bf8991eefffb1f8d13ca700

# initial_rev subprojects/boost_math/math: c114cf4a6ae958ce87ed6db4d55c1db4ec0a9c74

# initial_rev subprojects/cobyqa: 69b7177b9febb9178a5f7a9d61200407f1f77d25

# initial_rev subprojects/highs: 4f96ee8f40b2d3a46e00d6137d5eb31044680776

# initial_rev subprojects/unuran: 7e2344e93eb688acc430393c12228419fa130b9b

# initial_rev subprojects/xsf: f7b85f505a94fd398024478d2e747b01dd2d7a6d
