inherit externalsrc
EXTERNALSRC = "/home/google/SymonSaysLLC/Symoneural-Ravencalc/src/numerics/source/numpy"

# initial_rev .: dd88c0c19b54ad9ed3533224221285bf0873249a

# initial_rev doc/source/_static/scipy-mathjax: 36f4c898f2255e0c98eb6949cd67381552d5ffea

# initial_rev numpy/_core/src/common/pythoncapi-compat: 8636bccf29adfa23463f810b3c2830f7cff1e933

# initial_rev numpy/_core/src/highway: ee36c837129310be19c17c9108c6dc3f6ae06942

# initial_rev numpy/_core/src/npysort/x86-simd-sort: fa944efbea1a33426b3f8a9a21e23794ab8aa300

# initial_rev numpy/_core/src/umath/svml: bd9d46e0c627ab16f3d2641f7cdb1bc15d303ba4

# initial_rev numpy/fft/pocketfft: 33ae5dc94c9cdc7f1c78346504a85de87cadaa12

# initial_rev vendored-meson/meson: 983fca5b39b62060c733a58fd8ecd276591bdf12
