inherit externalsrc
EXTERNALSRC = "/home/google/SymonSaysLLC/Symoneural-Ravencalc/src/ml/source/scikit-learn"

# initial_rev .: 866c0f51e7560ef0303cbcc5f159df5382ea9e3f
