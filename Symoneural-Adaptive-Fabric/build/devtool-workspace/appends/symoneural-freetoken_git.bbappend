inherit externalsrc
EXTERNALSRC = "/home/google/SymonSaysLLC/Symoneural-Adaptive-Fabric/src/freetoken/source/FreeToken"
EXTERNALSRC_BUILD = "/home/google/SymonSaysLLC/Symoneural-Adaptive-Fabric/src/freetoken/source/FreeToken"

# initial_rev .: 9db1a39455a3fb107f3db83e381d10ceadfe5d99
