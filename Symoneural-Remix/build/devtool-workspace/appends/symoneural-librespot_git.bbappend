inherit externalsrc
EXTERNALSRC = "/home/google/SymonSaysLLC/Symoneural-Remix/src/librespot/source/librespot"
EXTERNALSRC_BUILD = "/home/google/SymonSaysLLC/Symoneural-Remix/src/librespot/source/librespot"

# initial_rev .: d36f9f1907e8cc9d68a93f8ebc6b627b1bf7267d
