inherit externalsrc
EXTERNALSRC = "/home/google/SymonSaysLLC/Symoneural-API/src/http/source/httpx"
EXTERNALSRC_BUILD = "/home/google/SymonSaysLLC/Symoneural-API/src/http/source/httpx"

# initial_rev .: 26d48e0634e6ee9cdc0533996db289ce4b430177
