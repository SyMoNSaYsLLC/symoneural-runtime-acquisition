inherit externalsrc
EXTERNALSRC = "/home/google/SymonSaysLLC/Symoneural-API/src/http/source/httpcore"
EXTERNALSRC_BUILD = "/home/google/SymonSaysLLC/Symoneural-API/src/http/source/httpcore"

# initial_rev .: 98209758cc14e1a5f966fe1dfdc1064b94055d8c
