inherit externalsrc
EXTERNALSRC = "/home/google/SymonSaysLLC/Symoneural-API/src/web/source/starlette"
EXTERNALSRC_BUILD = "/home/google/SymonSaysLLC/Symoneural-API/src/web/source/starlette"

# initial_rev .: 4f250d6b814587e20c5365f0a5f0c4d42bcb929f
