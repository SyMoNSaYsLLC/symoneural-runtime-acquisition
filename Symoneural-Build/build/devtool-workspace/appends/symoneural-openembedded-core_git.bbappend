inherit externalsrc
EXTERNALSRC = "/home/google/SymonSaysLLC/Symoneural-Build/src/devtools/source/openembedded-core"
EXTERNALSRC_BUILD = "/home/google/SymonSaysLLC/Symoneural-Build/src/devtools/source/openembedded-core"

# initial_rev .: 2814f0962f56c8d1afa4de76d2895ba9b5cb767d
