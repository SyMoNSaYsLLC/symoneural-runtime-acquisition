inherit externalsrc
EXTERNALSRC = "/home/google/SymonSaysLLC/Symoneural-Build/src/autotools/source/automake"

# initial_rev .: e82d2d34d4626445565bc131f6580b59597d0c62
