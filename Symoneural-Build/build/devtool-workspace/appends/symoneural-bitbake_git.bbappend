inherit externalsrc
EXTERNALSRC = "/home/google/SymonSaysLLC/Symoneural-Build/src/bitbake/source"
EXTERNALSRC_BUILD = "/home/google/SymonSaysLLC/Symoneural-Build/src/bitbake/source"

# initial_rev .: 0880963fea4d91a034e4a6e007d23f98658ab986
