inherit externalsrc
EXTERNALSRC = "/home/google/SymonSaysLLC/Symoneural-Build/src/autotools/source/m4"

# initial_rev .: fe2f13ab9ab9b3e712c6529f0b2a49a81feb6ce2

# initial_rev gl-mod/bootstrap: a42785aaa63db8a824292f87bc1a3f8863942601

# initial_rev gnulib: c6842ec25c6d5b1596da4eb6b68603f9578b23e9
