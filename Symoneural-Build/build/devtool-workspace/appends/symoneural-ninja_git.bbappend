inherit externalsrc
EXTERNALSRC = "/home/google/SymonSaysLLC/Symoneural-Build/src/ninja/source/ninja"

# initial_rev .: 3441b633c2fe2c494e958780ba0f4227b1327634
