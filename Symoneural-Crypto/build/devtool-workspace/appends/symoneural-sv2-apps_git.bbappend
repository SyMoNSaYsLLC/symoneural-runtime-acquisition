inherit externalsrc
EXTERNALSRC = "/home/google/SymonSaysLLC/Symoneural-Crypto/src/stratum/source/sv2-apps"
EXTERNALSRC_BUILD = "/home/google/SymonSaysLLC/Symoneural-Crypto/src/stratum/source/sv2-apps"

# initial_rev .: d7d556d1a3c7e1c26dfccd076b491a38c038a5e0
