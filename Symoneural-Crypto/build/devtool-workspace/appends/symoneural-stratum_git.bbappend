inherit externalsrc
EXTERNALSRC = "/home/google/SymonSaysLLC/Symoneural-Crypto/src/stratum/source/stratum"
EXTERNALSRC_BUILD = "/home/google/SymonSaysLLC/Symoneural-Crypto/src/stratum/source/stratum"

# initial_rev .: c1a7991394254c806f97a5feb4f4be771596ce69
