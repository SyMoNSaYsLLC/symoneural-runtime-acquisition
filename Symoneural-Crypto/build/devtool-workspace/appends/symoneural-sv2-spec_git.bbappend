inherit externalsrc
EXTERNALSRC = "/home/google/SymonSaysLLC/Symoneural-Crypto/src/stratum/source/sv2-spec"
EXTERNALSRC_BUILD = "/home/google/SymonSaysLLC/Symoneural-Crypto/src/stratum/source/sv2-spec"

# initial_rev .: 67d2178e12b2c3da948f656b0e1030afafb8d891
