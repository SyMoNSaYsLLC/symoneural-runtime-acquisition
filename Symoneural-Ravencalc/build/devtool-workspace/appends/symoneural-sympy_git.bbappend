inherit externalsrc
EXTERNALSRC = "/home/google/SymonSaysLLC/Symoneural-Ravencalc/src/symbolic/source/sympy"
EXTERNALSRC_BUILD = "/home/google/SymonSaysLLC/Symoneural-Ravencalc/src/symbolic/source/sympy"

# initial_rev .: 16fa855354eb7bcabd3fe10993841e03b1382692
