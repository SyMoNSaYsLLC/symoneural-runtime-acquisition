inherit externalsrc
EXTERNALSRC = "/home/google/SymonSaysLLC/Symoneural-Ravencalc/src/symbolic/source/mpmath"
EXTERNALSRC_BUILD = "/home/google/SymonSaysLLC/Symoneural-Ravencalc/src/symbolic/source/mpmath"

# initial_rev .: c1131e2d64abcbb57728ca8a499c920c0c69e67f
