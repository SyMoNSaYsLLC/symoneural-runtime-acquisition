inherit externalsrc
EXTERNALSRC = "/home/google/SymonSaysLLC/Symoneural-Ravencalc/src/blas/source/openblas"

# initial_rev .: e0166008be8e466242aa76b2ff75ce3f0fbf574a
