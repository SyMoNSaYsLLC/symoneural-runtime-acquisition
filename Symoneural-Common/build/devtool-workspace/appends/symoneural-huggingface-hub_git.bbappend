inherit externalsrc
EXTERNALSRC = "/home/google/SymonSaysLLC/Symoneural-Common/src/ml/source/huggingface-hub"
EXTERNALSRC_BUILD = "/home/google/SymonSaysLLC/Symoneural-Common/src/ml/source/huggingface-hub"

# initial_rev .: 495b17c8529614759ae0f1ccf1ebe9a61c148b7c
