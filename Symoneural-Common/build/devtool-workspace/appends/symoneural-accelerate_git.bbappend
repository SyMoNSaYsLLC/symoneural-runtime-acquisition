inherit externalsrc
EXTERNALSRC = "/home/google/SymonSaysLLC/Symoneural-Common/src/ml/source/accelerate"
EXTERNALSRC_BUILD = "/home/google/SymonSaysLLC/Symoneural-Common/src/ml/source/accelerate"

# initial_rev .: 6afc1e5ee217051fde702b23de2813344dc0fd33
