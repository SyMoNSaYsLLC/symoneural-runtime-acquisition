inherit externalsrc
EXTERNALSRC = "/home/google/SymonSaysLLC/Symoneural-Common/src/ml/source/pytorch"

# initial_rev .: 2b3ec34829036a65cd9d1398ea72a0167dc37470
