inherit externalsrc
EXTERNALSRC = "/home/google/SymonSaysLLC/Symoneural-LLM/src/inference/source/triton"
EXTERNALSRC_BUILD = "/home/google/SymonSaysLLC/Symoneural-LLM/src/inference/source/triton"

# initial_rev .: c01b6774b1865984607d89d89d3a10833de92037
