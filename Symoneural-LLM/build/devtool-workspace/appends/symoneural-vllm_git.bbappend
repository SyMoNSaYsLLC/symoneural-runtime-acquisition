inherit externalsrc
EXTERNALSRC = "/home/google/SymonSaysLLC/Symoneural-LLM/src/inference/source/vllm"
EXTERNALSRC_BUILD = "/home/google/SymonSaysLLC/Symoneural-LLM/src/inference/source/vllm"

# initial_rev .: 98dff2a81d747d1dba01a47f939f48c3526d4206
