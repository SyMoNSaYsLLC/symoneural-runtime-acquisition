# Recipe created by recipetool
# This is the basis of a recipe and may need further editing in order to be fully functional.
# (Feel free to remove these comments when editing.)

# WARNING: the following LICENSE and LIC_FILES_CHKSUM values are best guesses - it is
# your responsibility to verify that the values are complete and correct.
#
# NOTE: multiple licenses have been detected; they have been separated with &
# in the LICENSE value for now since it is a reasonable assumption that all
# of the licenses apply. If instead there is a choice between the multiple
# licenses then you should change the value to separate the licenses with |
# instead of &. If there is any doubt, check the accompanying documentation
# to determine which situation is applicable.
LICENSE = "Apache-2.0 AND MIT"
LIC_FILES_CHKSUM = "file://LICENSE;md5=86d3f3a95c324c9479bd8986968f4327 \
                    file://vllm/third_party/flash_linear_attention/LICENSE;md5=736e631fc66c620b9a29da9df68ec51e"

SRC_URI = "git://github.com/vllm-project/vllm;protocol=https;branch=releases/v0.29.0"

# Modify these as desired
PV = "1.0+git"
SRCREV = "98dff2a81d747d1dba01a47f939f48c3526d4206"

S = "${WORKDIR}/git"

inherit python_setuptools_build_meta setuptools3

# The following configs & dependencies are from setuptools extras_require.
# These dependencies are optional, hence can be controlled via PACKAGECONFIG.
# The upstream names may not correspond exactly to bitbake package names.
# The configs are might not correct, since PACKAGECONFIG does not support expressions as may used in requires.txt - they are just replaced by text.
#
# Uncomment this line to enable all the optional features.
#PACKAGECONFIG ?= "zen bench tensorizer fastsafetensors instanttensor runai audio video deepstream flashinfer b12x helion grpc otel extra-quant"
PACKAGECONFIG[zen] = ",,,python3-zentorch"
PACKAGECONFIG[bench] = ",,,python3-datasets python3-matplotlib python3-pandas python3-plotly python3-scipy python3-seaborn"
PACKAGECONFIG[tensorizer] = ",,,python3-tensorizer"
PACKAGECONFIG[fastsafetensors] = ",,,python3-fastsafetensors"
PACKAGECONFIG[instanttensor] = ",,,python3-instanttensor"
PACKAGECONFIG[runai] = ",,,python3-runai-model-streamer"
PACKAGECONFIG[audio] = ",,,python3-av python3-mistral_common python3-scipy python3-soundfile python3-soxr"
PACKAGECONFIG[video] = ",,,"
PACKAGECONFIG[deepstream] = ",,,python3-nvidia-deepstream-videodecode-cu13"
PACKAGECONFIG[flashinfer] = ",,,"
PACKAGECONFIG[b12x] = ",,,python3-b12x"
PACKAGECONFIG[helion] = ",,,python3-helion"
PACKAGECONFIG[grpc] = ",,,python3-smg-grpc-servicer"
PACKAGECONFIG[otel] = ",,,python3-opentelemetry-api python3-opentelemetry-exporter-otlp python3-opentelemetry-sdk python3-opentelemetry-semantic-conventions-ai"
PACKAGECONFIG[extra-quant] = ",,,python3-vllm-gguf-plugin"

# WARNING: the following rdepends are determined through basic analysis of the
# python sources, and might not be 100% accurate.
RDEPENDS:${PN} += "python3-core"

# WARNING: We were unable to map the following python package/module
# dependencies to the bitbake packages which include them:
#    PIL
#    PIL.Image
#    PyNvVideoCodec
#    __future__
#    _hashlib
#    _pytest.monkeypatch
#    _pytest.outcomes
#    _typeshed
#    abc
#    aiohttp
#    aiter
#    aiter.dist.device_communicators.custom_all_reduce
#    aiter.fused_moe
#    aiter.fused_moe_bf16_asm
#    aiter.jit.core
#    aiter.mla
#    aiter.ops.flydsl
#    aiter.ops.flydsl.kernels.moe_gemm_2stage
#    aiter.ops.flydsl.moe_common
#    aiter.ops.flydsl.utils
#    aiter.ops.fused_qk_norm_rope_cache_quant
#    aiter.ops.fused_qk_rmsnorm_group_quant
#    aiter.ops.gemm_op_a8w8
#    aiter.ops.mhc
#    aiter.ops.quant
#    aiter.ops.sampling
#    aiter.ops.shuffle
#    aiter.ops.topk
#    aiter.ops.triton.activation
#    aiter.ops.triton.attention.mha_v3
#    aiter.ops.triton.attention.mla
#    aiter.ops.triton.batched_gemm_a16wfp4
#    aiter.ops.triton.batched_gemm_a8w8_a_per_token_group_prequant_w_per_batched_tensor_quant
#    aiter.ops.triton.causal_conv1d_update_single_token
#    aiter.ops.triton.conv.conv2d
#    aiter.ops.triton.fused_add_rmsnorm_pad
#    aiter.ops.triton.fused_fp8_quant
#    aiter.ops.triton.fused_kv_cache
#    aiter.ops.triton.fusions.fused_clamp_act_mul
#    aiter.ops.triton.gated_delta_net
#    aiter.ops.triton.gated_delta_net.fused_rearrange_sigmoid_gdr
#    aiter.ops.triton.gemm_a16w16
#    aiter.ops.triton.gemm_a8w8_blockscale
#    aiter.ops.triton.gemm_a8wfp4
#    aiter.ops.triton.gemm_afp4wfp4
#    aiter.ops.triton.gluon.mla_decode_gluon
#    aiter.ops.triton.gluon.mla_gluon
#    aiter.ops.triton.gluon.pa_decode_gluon
#    aiter.ops.triton.mha
#    aiter.ops.triton.moe.moe_op_gemm_a16w4
#    aiter.ops.triton.moe.moe_routing
#    aiter.ops.triton.moe.quant_moe
#    aiter.ops.triton.moe_op_gemm_a8w4
#    aiter.ops.triton.moe_routing
#    aiter.ops.triton.quant
#    aiter.ops.triton.quant_moe
#    aiter.ops.triton.rope.rope
#    aiter.ops.triton.unified_attention
#    aiter.test_common
#    aiter.tuned_gemm
#    aiter.utility.fp4_utils
#    amdsmi
#    anthropic
#    arctic_inference.suffix_decoding
#    argparse
#    ast
#    asyncio
#    auto_round_kernel
#    auto_round_kernel.qlinear
#    bisect
#    blake3
#    boto3
#    botocore.client
#    cachetools
#    cbor2
#    cloudpickle
#    codecs
#    cohere
#    cohere.types
#    cohere_melody
#    collections
#    collections.abc
#    compressed_tensors
#    compressed_tensors.compressors.pack_quantized.helpers
#    compressed_tensors.compressors.quantized_compressors.pack_quantized
#    compressed_tensors.config
#    compressed_tensors.quantization
#    compressed_tensors.transform
#    compressed_tensors.transform.utils.hadamard
#    compressed_tensors.utils
#    conch.ops.quantization.gemm
#    concurrent
#    concurrent.futures
#    concurrent.futures._base
#    concurrent.futures.process
#    contextlib
#    contextvars
#    copy
#    copyreg
#    cpuinfo
#    csv
#    ctypes
#    ctypes.util
#    cuda
#    cuda.bindings
#    cuda.bindings.driver
#    cutlass
#    cutlass._mlir
#    cutlass._mlir.dialects
#    cutlass.cute
#    cutlass.cute.nvgpu
#    cutlass.cute.nvgpu.common
#    cutlass.cute.runtime
#    cutlass.cutlass_dsl
#    cutlass.pipeline
#    cutlass.utils
#    cv2
#    cv2.videoio_registry
#    dataclasses
#    datetime
#    deep_ep
#    deep_gemm.utils.math
#    depyf
#    dummy_stat_logger.dummy_stat_logger
#    einops
#    enum
#    fastapi
#    fastapi.exceptions
#    fastapi.openapi.docs
#    fastapi.responses
#    fastapi.staticfiles
#    fastapi.testclient
#    fastsafetensors.parallel_loader
#    fbgemm_gpu
#    fbgemm_gpu.experimental.gemm.triton_gemm.fp4_quantize
#    filecmp
#    filelock
#    flag_gems
#    flash_attn
#    flashinfer
#    flashinfer.autotuner
#    flashinfer.comm
#    flashinfer.comm.mnnvl
#    flashinfer.comm.trtllm_alltoall
#    flashinfer.comm.trtllm_moe_alltoall
#    flashinfer.concat_ops
#    flashinfer.cute_dsl.utils
#    flashinfer.decode
#    flashinfer.fp4_quantization
#    flashinfer.fused_moe
#    flashinfer.fused_moe.core
#    flashinfer.gdn_prefill
#    flashinfer.jit
#    flashinfer.mamba
#    flashinfer.moe_ep
#    flashinfer.moe_ep.core.runtime
#    flashinfer.norm
#    flashinfer.prefill
#    flashinfer.rope
#    flashinfer.sampling
#    flashinfer.testing
#    flashinfer.utils
#    flexkv.integration.vllm.vllm_v1_adapter
#    flydsl._mlir
#    flydsl._mlir.dialects
#    flydsl.compiler
#    flydsl.compiler.kernel_function
#    flydsl.expr
#    flydsl.expr.typing
#    flydsl.runtime.device
#    flydsl.utils.smem_allocator
#    fnmatch
#    fractions
#    functools
#    getpass
#    glob
#    gpt_oss.tools.python_docker.docker_tool
#    gpt_oss.tools.simple_browser
#    gpt_oss.tools.simple_browser.backend
#    grpc
#    grpc_health.v1
#    grpc_reflection.v1alpha
#    hashlib
#    heapq
#    helion._compat
#    helion._compiler._dynamo.higher_order_ops
#    helion._compiler._dynamo.variables
#    helion.autotuner.base_search
#    helion.language
#    helion.runtime.config
#    helion.runtime.kernel
#    helion.runtime.settings
#    hf3fs_fuse.io
#    hpc
#    hpc.gemm
#    http
#    http.server
#    httpx
#    huggingface_hub
#    huggingface_hub.constants
#    huggingface_hub.dataclasses
#    huggingface_hub.errors
#    huggingface_hub.utils
#    hypothesis
#    ijson
#    imagehash
#    importlib
#    importlib.abc
#    importlib.machinery
#    importlib.metadata
#    importlib.util
#    inspect
#    io
#    ipaddress
#    jinja2
#    jinja2.ext
#    jinja2.meta
#    jinja2.nodes
#    jinja2.parser
#    jinja2.sandbox
#    jiwer
#    json
#    json.decoder
#    jsonschema
#    kaldi_native_fbank
#    keyword
#    lark
#    libtpu
#    llguidance
#    llguidance.hf
#    llguidance.torch
#    lm_eval
#    lmcache
#    lmcache.config
#    lmcache.integration.vllm.lmcache_mp_connector
#    lmcache.integration.vllm.utils
#    lmcache.integration.vllm.vllm_multi_process_adapter
#    lmcache.integration.vllm.vllm_v1_adapter
#    lmcache.logging
#    lmcache.observability
#    lmcache.utils
#    lmcache.v1.cache_engine
#    lmcache.v1.compute.blend
#    lmcache.v1.config
#    lmcache.v1.gpu_connector
#    lmcache.v1.internal_api_server.api_server
#    lmcache.v1.lookup_client
#    lmcache.v1.lookup_client.lmcache_async_lookup_client
#    lmcache.v1.multiprocess.custom_types
#    lmcache.v1.multiprocess.mq
#    lmcache.v1.multiprocess.protocol
#    lmcache.v1.offload_server.zmq_server
#    lmcache.v1.plugin.plugin_launcher
#    lmcache.v1.plugin.runtime_plugin_launcher
#    lmformatenforcer
#    lmformatenforcer.integrations.vllm
#    locale
#    logging
#    logging.config
#    logging.handlers
#    lxml
#    matplotlib.pyplot
#    mcp
#    mcp.client
#    mcp.client.sse
#    mcp.types
#    mimetypes
#    mistral_common.audio
#    mistral_common.exceptions
#    mistral_common.guidance.grammar_factory
#    mistral_common.guidance.tokenizer
#    mistral_common.multimodal
#    mistral_common.protocol.instruct.chunk
#    mistral_common.protocol.instruct.messages
#    mistral_common.protocol.instruct.request
#    mistral_common.protocol.instruct.tool_calls
#    mistral_common.protocol.instruct.validator
#    mistral_common.protocol.transcription.request
#    mistral_common.tokens.tokenizers.audio
#    mistral_common.tokens.tokenizers.base
#    mistral_common.tokens.tokenizers.instruct
#    mistral_common.tokens.tokenizers.mistral
#    mistral_common.tokens.tokenizers.multimodal
#    mistral_common.tokens.tokenizers.sentencepiece
#    mistral_common.tokens.tokenizers.tekken
#    mmap
#    model_hosting_container_standards.common.fastapi.config
#    model_hosting_container_standards.common.fastapi.middleware
#    model_hosting_container_standards.common.fastapi.middleware.source.decorator_loader
#    model_hosting_container_standards.common.handler
#    model_hosting_container_standards.sagemaker
#    model_hosting_container_standards.sagemaker.config
#    model_hosting_container_standards.sagemaker.sagemaker_loader
#    modelscope
#    modelscope.hub.api
#    modelscope.hub.snapshot_download
#    modelscope.utils.file_utils
#    modelscope.utils.hf_util
#    mooncake.engine
#    mooncake.store
#    mori
#    mori.io
#    msgpack
#    msgspec
#    msgspec.msgpack
#    mteb
#    mteb.models
#    mteb.types
#    multiprocess
#    multiprocessing
#    multiprocessing.connection
#    multiprocessing.forkserver
#    multiprocessing.process
#    multiprocessing.queues
#    multiprocessing.synchronize
#    nixl._api
#    nixl_ep
#    numba
#    numbers
#    numpy
#    numpy.typing
#    nvidia.deepstream_videodecode
#    nvtx
#    openai
#    openai.types.chat
#    openai.types.chat.chat_completion
#    openai.types.chat.chat_completion_audio
#    openai.types.chat.chat_completion_chunk
#    openai.types.chat.chat_completion_content_part_image_param
#    openai.types.chat.chat_completion_content_part_input_audio_param
#    openai.types.chat.chat_completion_message
#    openai.types.chat.chat_completion_message_tool_call_param
#    openai.types.completion
#    openai.types.responses
#    openai.types.responses.function_tool
#    openai.types.responses.response
#    openai.types.responses.response_format_text_json_schema_config
#    openai.types.responses.response_function_tool_call
#    openai.types.responses.response_function_tool_call_output_item
#    openai.types.responses.response_function_web_search
#    openai.types.responses.response_output_item
#    openai.types.responses.response_output_message
#    openai.types.responses.response_output_text
#    openai.types.responses.response_reasoning_item
#    openai.types.responses.tool
#    openai.types.responses.tool_choice_allowed
#    openai.types.responses.tool_choice_function
#    openai.types.responses.tool_param
#    openai.types.shared
#    openai_harmony
#    opentelemetry
#    opentelemetry.context.context
#    opentelemetry.exporter.otlp.proto.grpc.trace_exporter
#    opentelemetry.exporter.otlp.proto.http.trace_exporter
#    opentelemetry.propagate
#    opentelemetry.proto.collector.trace.v1.trace_service_pb2
#    opentelemetry.proto.collector.trace.v1.trace_service_pb2_grpc
#    opentelemetry.proto.common.v1.common_pb2
#    opentelemetry.sdk.environment_variables
#    opentelemetry.sdk.resources
#    opentelemetry.sdk.trace
#    opentelemetry.sdk.trace.export
#    opentelemetry.trace
#    opentelemetry.trace.propagation.tracecontext
#    operator
#    orjson
#    os
#    outlines_core
#    outlines_core.json_schema
#    packaging
#    packaging.version
#    partial_json_parser
#    partial_json_parser.core.complete
#    partial_json_parser.core.options
#    pathlib
#    perceptron.tensorstream
#    perceptron.tensorstream.ops
#    pickle
#    pkgutil
#    platform
#    plotly.express
#    plotly.io
#    pprint
#    pqdm.threads
#    prometheus_client
#    prometheus_client.parser
#    prometheus_client.samples
#    prometheus_fastapi_instrumentator
#    psutil
#    pybase64
#    pydantic
#    pydantic.dataclasses
#    pydantic.fields
#    pydantic_core
#    pydantic_core.core_schema
#    pytest
#    pytest_asyncio
#    quack.compile_utils
#    quark.torch.export.nn.modules.realquantizer
#    quark.torch.kernel
#    quark.torch.kernel.hw_emulation.hw_emulation_interface
#    quark.torch.kernel.mx
#    quark.torch.quantization.config.config
#    quark.torch.quantization.utils
#    quark.torch.utils.pack
#    queue
#    random
#    rapidfuzz
#    ray
#    ray._private.accelerators
#    ray._private.state
#    ray.actor
#    ray.dag
#    ray.exceptions
#    ray.experimental
#    ray.experimental.channel.accelerator_context
#    ray.experimental.channel.communicator
#    ray.experimental.tqdm_ray
#    ray.runtime_env
#    ray.types
#    ray.util
#    ray.util.metrics
#    ray.util.placement_group
#    ray.util.scheduling_strategies
#    ray.util.state
#    regex
#    requests
#    requests.adapters
#    resource
#    rich.console
#    rich.table
#    runai_model_streamer
#    runai_model_streamer.safetensors_streamer.streamer_mock
#    runpy
#    safetensors
#    safetensors.torch
#    schemathesis
#    schemathesis.config
#    scipy.integrate
#    scipy.signal
#    scipy.stats
#    secrets
#    sentence_transformers
#    setproctitle
#    shlex
#    shutil
#    signal
#    smg_grpc_proto
#    smg_grpc_servicer.vllm.health_servicer
#    smg_grpc_servicer.vllm.servicer
#    socket
#    sqlite3
#    sre_constants
#    sre_parse
#    ssl
#    starlette.background
#    starlette.concurrency
#    starlette.datastructures
#    starlette.middleware.base
#    starlette.middleware.cors
#    starlette.requests
#    starlette.responses
#    starlette.routing
#    starlette.testclient
#    starlette.types
#    starlette.websockets
#    statistics
#    string
#    struct
#    subprocess
#    sympy
#    tabulate
#    tblib
#    tempfile
#    tensorizer.stream_io
#    tensorizer.utils
#    termplotlib
#    terratorch.vllm
#    tests.evals.gsm8k.gsm8k_eval
#    tests.kernels.quantization.nvfp4_utils
#    tests.v1.attention.utils
#    textwrap
#    threading
#    tiktoken
#    tilelang
#    tilelang.jit
#    tilelang.jit.kernel
#    tilelang.language
#    timm
#    timm.layers
#    timm.layers.pos_embed
#    timm.models.regnet
#    tokenizers
#    tokenizers.decoders
#    tools.pre_commit.validate_config
#    torch
#    torch._C
#    torch._C._autograd
#    torch._C._distributed_c10d
#    torch._C._profiler
#    torch._dynamo
#    torch._dynamo.aot_compile
#    torch._dynamo.backends.registry
#    torch._dynamo.config
#    torch._dynamo.convert_frame
#    torch._dynamo.decorators
#    torch._dynamo.exc
#    torch._dynamo.guards
#    torch._dynamo.package
#    torch._dynamo.source
#    torch._dynamo.symbolic_convert
#    torch._dynamo.utils
#    torch._dynamo.variables.builder
#    torch._dynamo.variables.torch
#    torch._functorch
#    torch._functorch._aot_autograd.autograd_cache
#    torch._functorch.config
#    torch._guards
#    torch._higher_order_ops
#    torch._higher_order_ops.auto_functionalize
#    torch._higher_order_ops.triton_kernel_wrap
#    torch._inductor
#    torch._inductor.codecache
#    torch._inductor.codegen.cpp
#    torch._inductor.codegen.wrapper
#    torch._inductor.compile_fx
#    torch._inductor.config
#    torch._inductor.custom_graph_pass
#    torch._inductor.fx_passes
#    torch._inductor.fx_passes.joint_graph
#    torch._inductor.fx_passes.post_grad
#    torch._inductor.graph
#    torch._inductor.ir
#    torch._inductor.lowering
#    torch._inductor.output_code
#    torch._inductor.pattern_matcher
#    torch._inductor.runtime.triton_helpers
#    torch._inductor.runtime.triton_heuristics
#    torch._inductor.scheduler
#    torch._inductor.standalone_compile
#    torch._inductor.utils
#    torch._inductor.virtualized
#    torch._library.fake_class_registry
#    torch._library.opaque_object
#    torch._logging
#    torch._logging._internal
#    torch._opaque_base
#    torch._ops
#    torch._prims_common
#    torch._subclasses
#    torch._subclasses.fake_tensor
#    torch._tensor_str
#    torch.autograd.profiler
#    torch.backends.cudnn
#    torch.backends.xnnpack
#    torch.cuda
#    torch.cuda.memory
#    torch.cuda.nvtx
#    torch.cuda.profiler
#    torch.distributed
#    torch.distributed._functional_collectives
#    torch.distributed._symmetric_memory
#    torch.distributed.algorithms._checkpoint.checkpoint_wrapper
#    torch.distributed.distributed_c10d
#    torch.distributed.fsdp.fully_sharded_data_parallel
#    torch.distributed.rendezvous
#    torch.func
#    torch.fx
#    torch.fx._graph_pickler
#    torch.fx._lazy_graph_module
#    torch.fx._utils
#    torch.fx.experimental.proxy_tensor
#    torch.fx.experimental.symbolic_shapes
#    torch.fx.node
#    torch.library
#    torch.multiprocessing
#    torch.multiprocessing.reductions
#    torch.nn
#    torch.nn.attention
#    torch.nn.attention.flex_attention
#    torch.nn.functional
#    torch.nn.init
#    torch.nn.modules.module
#    torch.nn.parameter
#    torch.nn.utils.rnn
#    torch.profiler
#    torch.types
#    torch.utils
#    torch.utils._appending_byte_serializer
#    torch.utils._config_module
#    torch.utils._ordered_set
#    torch.utils._python_dispatch
#    torch.utils._sympy.value_ranges
#    torch.utils.benchmark
#    torch.utils.cpp_extension
#    torch.utils.data
#    torchao.core.config
#    torchao.prototype.safetensors.safetensors_support
#    torchao.prototype.tensor_conversion.api
#    torchao.quantization
#    torchao.utils
#    torchaudio
#    torchaudio.compliance.kaldi
#    torchaudio.functional
#    torchaudio.transforms
#    torchcodec
#    torchcodec.decoders
#    torchvision
#    torchvision.transforms
#    torchvision.transforms.functional
#    tpu_inference
#    tpu_inference.platforms
#    tqdm
#    tqdm.asyncio
#    tqdm.auto
#    traceback
#    transformers
#    transformers.activations
#    transformers.audio_utils
#    transformers.configuration_utils
#    transformers.conversion_mapping
#    transformers.convert_slow_tokenizer
#    transformers.dynamic_module_utils
#    transformers.feature_extraction_sequence_utils
#    transformers.feature_extraction_utils
#    transformers.file_utils
#    transformers.generation.utils
#    transformers.image_processing_base
#    transformers.image_processing_utils
#    transformers.image_processing_utils_fast
#    transformers.image_utils
#    transformers.masking_utils
#    transformers.modeling_outputs
#    transformers.modeling_rope_utils
#    transformers.modeling_utils
#    transformers.models.aria.modeling_aria
#    transformers.models.aria.processing_aria
#    transformers.models.audioflamingo3
#    transformers.models.auto
#    transformers.models.auto.auto_factory
#    transformers.models.auto.configuration_auto
#    transformers.models.auto.image_processing_auto
#    transformers.models.auto.modeling_auto
#    transformers.models.auto.tokenization_auto
#    transformers.models.auto.video_processing_auto
#    transformers.models.blip_2.configuration_blip_2
#    transformers.models.cohere2_vision
#    transformers.models.cohere2_vision.image_processing_cohere2_vision_fast
#    transformers.models.cohere2_vision.processing_cohere2_vision
#    transformers.models.deepseek_v2.configuration_deepseek_v2
#    transformers.models.deepseek_v2.modeling_deepseek_v2
#    transformers.models.exaone4_5
#    transformers.models.exaone4_5.configuration_exaone4_5
#    transformers.models.gemma3.image_processing_gemma3
#    transformers.models.gemma3.processing_gemma3
#    transformers.models.gemma3n
#    transformers.models.gemma3n.configuration_gemma3n
#    transformers.models.gemma4
#    transformers.models.gemma4.configuration_gemma4
#    transformers.models.gemma4_unified.configuration_gemma4_unified
#    transformers.models.gemma4_unified.processing_gemma4_unified
#    transformers.models.glm4_moe
#    transformers.models.glm4_moe_lite
#    transformers.models.glm4v.configuration_glm4v
#    transformers.models.glm4v.image_processing_glm4v
#    transformers.models.glm4v.video_processing_glm4v
#    transformers.models.glm_ocr.configuration_glm_ocr
#    transformers.models.glmasr
#    transformers.models.got_ocr2.image_processing_got_ocr2_fast
#    transformers.models.granitemoeshared
#    transformers.models.idefics2.configuration_idefics2
#    transformers.models.internvl.video_processing_internvl
#    transformers.models.lfm2_vl
#    transformers.models.lfm2_vl.configuration_lfm2_vl
#    transformers.models.lfm2_vl.image_processing_lfm2_vl_fast
#    transformers.models.llama4
#    transformers.models.llama4.image_processing_llama4_fast
#    transformers.models.llava
#    transformers.models.llava_next.modeling_llava_next
#    transformers.models.llava_onevision.modeling_llava_onevision
#    transformers.models.pixtral
#    transformers.models.pixtral.image_processing_pixtral
#    transformers.models.pixtral.modeling_pixtral
#    transformers.models.qwen2
#    transformers.models.qwen2.configuration_qwen2
#    transformers.models.qwen2.modeling_qwen2
#    transformers.models.qwen2_5_omni.configuration_qwen2_5_omni
#    transformers.models.qwen2_5_omni.modeling_qwen2_5_omni
#    transformers.models.qwen2_5_omni.processing_qwen2_5_omni
#    transformers.models.qwen2_5_vl
#    transformers.models.qwen2_5_vl.configuration_qwen2_5_vl
#    transformers.models.qwen2_audio
#    transformers.models.qwen2_vl
#    transformers.models.qwen2_vl.configuration_qwen2_vl
#    transformers.models.qwen2_vl.image_processing_qwen2_vl
#    transformers.models.qwen3_omni_moe.configuration_qwen3_omni_moe
#    transformers.models.qwen3_omni_moe.processing_qwen3_omni_moe
#    transformers.models.qwen3_vl
#    transformers.models.qwen3_vl.configuration_qwen3_vl
#    transformers.models.qwen3_vl.processing_qwen3_vl
#    transformers.models.qwen3_vl.video_processing_qwen3_vl
#    transformers.models.qwen3_vl_moe.configuration_qwen3_vl_moe
#    transformers.models.siglip
#    transformers.models.siglip2.configuration_siglip2
#    transformers.models.siglip2.image_processing_siglip2
#    transformers.models.whisper
#    transformers.models.whisper.configuration_whisper
#    transformers.models.whisper.english_normalizer
#    transformers.models.whisper.modeling_whisper
#    transformers.models.whisper.tokenization_whisper
#    transformers.processing_utils
#    transformers.tokenization_mistral_common
#    transformers.tokenization_utils_base
#    transformers.tokenization_utils_tokenizers
#    transformers.utils
#    transformers.utils.chat_template_utils
#    transformers.utils.output_capturing
#    transformers.video_processing_utils
#    transformers.video_utils
#    transformers_modules
#    triton
#    triton.backends
#    triton.compiler.errors
#    triton.experimental
#    triton.experimental.gluon
#    triton.language
#    triton.language.core
#    triton.language.extra.libdevice
#    triton.runtime
#    triton.runtime.errors
#    triton.testing
#    triton_kernels
#    triton_kernels.matmul_ogs
#    triton_kernels.matmul_ogs_details.opt_flags
#    triton_kernels.numerics
#    triton_kernels.numerics_details.mxfp
#    triton_kernels.routing
#    triton_kernels.routing_details
#    triton_kernels.swiglu
#    triton_kernels.tensor
#    triton_kernels.tensor_details
#    triton_kernels.tensor_details.bitmatrix
#    triton_kernels.tensor_details.bitmatrix_details.sum_bitmatrix_rows
#    triton_kernels.tensor_details.layout
#    triton_kernels.testing
#    triton_kernels.topk
#    types
#    typing
#    typing_extensions
#    unittest
#    unittest.mock
#    urllib.parse
#    urllib.request
#    urllib3
#    urllib3.util
#    urllib3.util.retry
#    uuid
#    uvicorn
#    uvloop
#    vllm._C
#    vllm._C_AVX2
#    vllm._C_AVX512
#    vllm._C_stable_libtorch
#    vllm._flashkda_C
#    vllm._flashmla_C
#    vllm._flashmla_extension_C
#    vllm._moe_C
#    vllm._moe_C_stable_libtorch
#    vllm._qutlass_C
#    vllm._rocm_C
#    vllm._version
#    vllm.cumem_allocator
#    vllm.fs_io_C
#    vllm.spinloop
#    vllm.third_party.deep_gemm
#    vllm.third_party.deep_gemm.utils
#    vllm.third_party.flashmla.flash_mla_interface
#    vllm.third_party.fmha_sm100.api
#    vllm.third_party.fmha_sm100.sparse
#    vllm.third_party.tml_fa4
#    vllm.third_party.triton_kernels
#    vllm.vllm_flash_attn.cute
#    vllm.vllm_flash_attn.cute.interface
#    vllm.vllm_flash_attn.cute.seqlen_info
#    vllm.vllm_flash_attn.cute.utils
#    vllm.vllm_flash_attn.layers.rotary
#    vllm_add_dummy_endpoint_plugin
#    vllm_bnb_plugin
#    vllm_omni.entrypoints.cli.main
#    vllm_test_utils.monitor
#    vllm_xpu_kernels
#    vllm_xpu_kernels._C
#    vllm_xpu_kernels._moe_C
#    vllm_xpu_kernels._xpu_C
#    vllm_xpu_kernels.flash_attn_interface
#    vllm_xpu_kernels.fused_moe_interface
#    warnings
#    watchfiles
#    weakref
#    websockets
#    xgrammar
#    xgrammar.openai_tool_call_schema
#    xgrammar.structural_tag
#    xgrammar.testing
#    xielu.ops
#    xml.etree.ElementTree
#    xml.parsers.expat
#    xxhash
#    yaml
#    zmq
#    zmq.asyncio
#    zmq.error
#    zmq.utils.monitor
