inherit externalsrc
EXTERNALSRC = "/home/google/SymonSaysLLC/Symoneural-CLI/src/mcp/source/python-sdk"
EXTERNALSRC_BUILD = "/home/google/SymonSaysLLC/Symoneural-CLI/src/mcp/source/python-sdk"

# initial_rev .: 9972c21aa42054fb1450c5fc614761ed11847ec6
