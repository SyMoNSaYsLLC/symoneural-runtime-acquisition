inherit externalsrc
EXTERNALSRC = "/home/google/SymonSaysLLC/Symoneural-CLI/src/anthropic/source/anthropic-sdk-python"
EXTERNALSRC_BUILD = "/home/google/SymonSaysLLC/Symoneural-CLI/src/anthropic/source/anthropic-sdk-python"

# initial_rev .: eb21a4352015686c30f5759e8c2f02d70f5371e2
